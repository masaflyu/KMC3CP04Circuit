# Repository masaflyu/KMC3CP04Circuit (continued)

## EAGLE design DueShield2/DueShield2.brd

Parts:
C1, C2: 100u; D=1,φ=6
CN1: CON6
CON1: DM1A-DSF-PEJDM1A-DSF-PEJ-FORHAND; DM1A-DSF-PEJ-FORHAND
CON2, CON3: CON4
CON4, CON5: CON3
D1, D2: 3.9V; SMD1206
IC1: LM358N; DIL08
J1, J2, J3, J4, J5, J6, J7: CON2
JP1, JP2, JP3, JP4, JP5: PINHD-1X7; 1X07
PCA9306: DIL8; DIL08
R1, R2: 100k; GF063PB
R3: THERMISTOR-2,5; RS-2,5
R5, R6: 10k; GF063PB
S1, S2: DTSM-3
U$1: DUE(3DPRINTER2); DUE(3DPRITNER2)
U$3, U$18, U$20, U$22, U$24, U$26, U$30, U$32, U$33, U$34, U$35, U$48, U$50: 10k; 0805(JIS2012)HAND
U$7, U$10, U$16, U$29: LED(砲弾型)3; LED3MM
U$8, U$9, U$40, U$47: 0.1u; 0805(JIS2012)HAND
U$11, U$12, U$39: 330; 0805(JIS2012)HAND
U$27, U$28: 100; 0805(JIS2012)HAND
U$31: 1k; 0805(JIS2012)HAND
U$41: (NOT USE); 0805(JIS2012)HAND
X1, X2: MKDSN1,5/2-5,08

Connections:
+3.3V: C1.+, CON1.4, CON2.P$1 (1), J1.P$2 (2), J3.P$2 (2), J4.P$2 (2), J5.P$2 (2), J6.P$2 (2), J7.P$2 (2), PCA9306.1, R5.P$2 (S), R6.P$2 (S), S1.2, S2.2, U$1.3V3, U$9.1, U$16.A, U$33.2, U$34.2, U$35.2, U$41.2, U$47.1
+5V: C2.+, CON3.P$1 (1), CON4.P$2 (2), CON5.P$2 (2), IC1.8 (V+), JP1.1, JP2.1, JP3.1, JP4.1, JP5.1, PCA9306.8, U$1.VIN, U$8.1, U$29.A, U$40.1
DGND: C1.-, C2.-, CON1.3, CON1.6, CON1.GND1, CON1.GND2, CON1.GND3, CON1.GND4, CON2.P$4 (4), CON3.P$4 (4), CON4.P$3 (3), CON5.P$3 (3), D1.2 (A), D2.2 (A), IC1.3 (+IN), IC1.4 (V-), IC1.5 (+IN), J2.P$2 (2), JP1.2, JP2.2, JP3.2, JP4.2, JP5.2, PCA9306.5, R3.2, U$1.5V_ICSP, U$1.GND1, U$1.GND_1, U$1.GND_2, U$3.1, U$8.2, U$9.2, U$11.1, U$12.1, U$18.1, U$20.1, U$22.1, U$24.1, U$26.1, U$30.1, U$31.1, U$32.1, U$39.1, U$40.2, U$47.2, U$48.1, U$50.1, X1.1, X2.1
unnamed: J1.P$1 (1), U$1.22, U$3.2
unnamed: S1.1, U$1.28, U$48.2
unnamed: CON1.1, U$1.10, U$41.1
unnamed: CON2.P$2 (2), PCA9306.2, U$1.SCL
unnamed: CON1.5, JP1.4, JP2.4, JP3.4, JP4.4, JP5.4, U$1.SCK_ICSP, U$34.1
unnamed: CON2.P$3 (3), PCA9306.3, U$1.SDA
unnamed: CON3.P$2 (2), PCA9306.7
unnamed: CON3.P$3 (3), PCA9306.6
unnamed: JP2.7, U$1.34
unnamed: JP3.7, U$1.35
unnamed: CN1.P$6 (6), U$1.2
unnamed: U$7.K, U$11.2
unnamed: U$10.K, U$12.2
unnamed: J2.P$1 (1), R6.P$1 (E), U$1.A2
unnamed: J3.P$1 (1), U$1.23, U$18.2
unnamed: CN1.P$5 (5), U$1.3
unnamed: CON4.P$1 (1), CON5.P$1 (1)
unnamed: R3.1, R5.P$1 (E), U$1.A3
unnamed: J4.P$1 (1), U$1.24, U$20.2
unnamed: J5.P$1 (1), U$1.25, U$22.2
unnamed: J6.P$1 (1), U$1.26, U$24.2
unnamed: J7.P$1 (1), U$1.27, U$26.2
unnamed: CN1.P$3 (3), U$1.5
unnamed: CN1.P$2 (2), U$1.6
unnamed: CN1.P$1 (1), U$1.7
unnamed: CN1.P$4 (4), U$1.4
unnamed: IC1.2 (-IN), R1.P$2 (S), U$27.2
unnamed: U$29.K, U$31.2
unnamed: IC1.6 (-IN), R2.P$2 (S), U$28.2
unnamed: U$28.1, X2.2
unnamed: U$27.1, X1.2
unnamed: D2.1 (C), IC1.1 (OUT), R1.P$3 (A), U$1.A0, U$30.2
unnamed: D1.1 (C), IC1.7 (OUT), R2.P$3 (A), U$1.A1, U$32.2
unnamed: JP4.7, U$1.36
unnamed: JP5.7, U$1.37
unnamed: U$16.K, U$39.2
unnamed: CON1.2, JP1.5, U$1.MOSI_ICSP, U$33.1
unnamed: CON1.7, JP5.6, U$1.MISO_ICSP, U$35.1
unnamed: JP2.6, JP3.5
unnamed: JP1.3, JP2.3, JP3.3, JP4.3, JP5.3, U$1.32
unnamed: JP1.7, U$1.33
unnamed: JP1.6, JP2.5
unnamed: S2.1, U$1.29, U$50.2
unnamed: JP3.6, JP4.5
unnamed: JP4.6, JP5.5
unnamed: U$1.30, U$7.A
unnamed: U$1.31, U$10.A

Notes on the sheet:
To High Power Output board
1 5V 2 GND 3 CS green 4 CK yellow 5 SDI orange 6 SDO red 7 BUSY brown

Board: 2 copper layers, 94.8 x 74.8 mm, 62 parts (21 on the bottom side), 50 nets.

## EAGLE design Distributer2/Distributer.brd

Parts:
CON1, CON2, CON3, CON4, CON5, CON6, CON7, CON8, CON9, CON10: CON3
R1, R2: 470; 0805
R3, R4: 1k; 0805
U$1, U$2, U$3, U$4: LED(砲弾型)3; LED3MM

Connections:
GND: CON1.P$3 (3), CON2.P$3 (3), CON3.P$3 (3), CON4.P$3 (3), CON5.P$3 (3), CON6.P$3 (3), CON7.P$3 (3), CON8.P$3 (3), CON9.P$3 (3), CON10.P$3 (3), U$1.K, U$2.K, U$3.K, U$4.K
unnamed: CON1.P$1 (1), CON2.P$1 (1), CON3.P$1 (1), CON4.P$1 (1), CON5.P$1 (1), CON6.P$1 (1), CON7.P$1 (1), CON8.P$1 (1), CON9.P$1 (1), CON10.P$1 (1), R1.1, R2.1
unnamed: CON1.P$2 (2), CON2.P$2 (2), CON3.P$2 (2), CON4.P$2 (2), CON5.P$2 (2), CON6.P$2 (2), CON7.P$2 (2), CON8.P$2 (2), CON9.P$2 (2), CON10.P$2 (2), R3.1, R4.1
unnamed: R2.2, U$2.A
unnamed: R3.2, U$3.A
unnamed: R4.2, U$4.A
unnamed: R1.2, U$1.A

Board: 2 copper layers, 12.5 x 90.0 mm, 18 parts (4 on the bottom side), 7 nets.

## EAGLE design newDCDC2/newDCDC.brd

Parts:
C1: 50V470uF; D=2,φ=10,5
C2: 35V1000uF; D=2,φ=13
CON2: CON3
J1, J2: CON2
U$1: SG-051A
U$2, U$3: LED(砲弾型)3; LED3MM
U$4: 4.7k; 0805(JIS2012)HAND
U$5: 1k; 0805(JIS2012)HAND

Connections:
+5V: C2.+, CON2.P$2 (2), U$1.P$5 (VOUT), U$3.A
+24V: C1.+, J1.P$1 (1), J2.P$1 (1), U$1.P$1 (VIN), U$2.A
GND: C1.-, C2.-, CON2.P$3 (3), J2.P$2 (2), U$1.P$3 (GND), U$4.2, U$5.2
unnamed: CON2.P$1 (1), J1.P$2 (2)
unnamed: U$1.P$4 (RELAY1), U$1.P$7 (COIL2)
unnamed: U$1.P$2 (RELAY2), U$1.P$8 (COIL1)
unnamed: U$2.K, U$4.1
unnamed: U$3.K, U$5.1

Board: 2 copper layers, 35.0 x 55.0 mm, 10 parts (2 on the bottom side), 8 nets.

## EAGLE design Shield/Shield.brd

Parts:
CON1: DM1A-DSF-PEJ
CON3: CON3
CON9, CON10: CON4
IC1: AD712N; DIL08
IR4427: DIL8; DIL08
J1, J2, J3, J4: CON2
JP1: PINHD-1X4; 1X04
PCA9306: DIL8S; SOCKET-08
R1, R2, R3: 470; 1/4W-H3_(0207/7)
R4, R5, R6: 1k; 1/4W-H3_(0207/7)
R7, R8, R9: 10k; 1/4W-H3_(0207/7)
R10: 10k; 1/4W-H4_(0207/10)
R12, R13, R14, R15: 100; 1/4W-H3_(0207/7)
R16, R17: 100k; GF063PB
R19, R20: 220?; 1/4W-H3_(0207/7)
R21: 10k; GF063PB
TR1: 10k(25C); RS-2,5
U$1: ARDUINO-IOPIN; ARDUINO-SHIELD-PIN-ONLY
U$7, U$8: TO-220(MOS-FET_N); TO-220
X1, X2, X3, X4: MKDSN1,5/2-5,08

Connections:
+3.3V: CON1.4, CON10.P$1 (1), PCA9306.1, U$1.3.3V (3,3V)
+5V: CON3.P$2 (2), CON9.P$1 (1), IC1.8 (V+), IR4427.6, J1.P$2 (2), J2.P$2 (2), J3.P$2 (2), J4.P$2 (2), PCA9306.8, R21.P$2 (S), U$1.VIN
+9V: CON3.P$1 (1), X1.2, X2.2
DGND: CON1.3, CON1.6, CON1.GND1, CON1.GND2, CON1.GND3, CON1.GND4, CON3.P$3 (3), CON9.P$4 (4), CON10.P$4 (4), IC1.4 (V-), IR4427.3, PCA9306.5, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, R13.1, R15.1, TR1.2, U$1.GND@1 (GND0), U$1.GND@2 (GND1), U$1.GND@3 (GND2), U$7.3 (S), U$8.3 (S), X3.1, X4.1
unnamed: CON1.2, R2.1, R5.2
unnamed: R1.2, U$1.D13
unnamed: CON1.5, R1.1, R4.2
unnamed: J1.P$1 (1), R7.2, U$1.D3
unnamed: R2.2, U$1.D11
unnamed: CON1.1, R3.1, R6.2
unnamed: R3.2, U$1.D4
unnamed: J2.P$1 (1), R8.2, U$1.D2
unnamed: CON1.7, U$1.D12
unnamed: J3.P$1 (1), R9.2, U$1.D1
unnamed: J4.P$1 (1), R10.2, U$1.D0
unnamed: CON10.P$2 (2), PCA9306.2
unnamed: CON9.P$3 (3), PCA9306.6, U$1.A4
unnamed: CON9.P$2 (2), PCA9306.7, U$1.A5
unnamed: CON10.P$3 (3), PCA9306.3
unnamed: IC1.2 (IN-), R12.2, R16.P$2 (S)
unnamed: IC1.3 (IN+), R13.2
unnamed: IC1.5 (IN+), R15.2
unnamed: IC1.6 (IN-), R14.2, R17.P$2 (S)
unnamed: IC1.1 (OUT), R16.P$3 (A), U$1.A0
unnamed: IC1.7 (OUT), R17.P$3 (A), U$1.A1
unnamed: JP1.4, U$1.D5
unnamed: JP1.3, U$1.D6
unnamed: JP1.2, U$1.D7
unnamed: JP1.1, U$1.D8
unnamed: U$7.2 (D), X1.1
unnamed: R19.2, U$7.1 (G)
unnamed: R21.P$1 (E), TR1.1, U$1.A2
unnamed: IR4427.2, U$1.D10
unnamed: IR4427.4, U$1.D9
unnamed: U$8.2 (D), X2.1
unnamed: R20.2, U$8.1 (G)
unnamed: IR4427.5, R19.1
unnamed: IR4427.7, R20.1
unnamed: R14.1, X4.2
unnamed: R12.1, X3.2

Notes on the sheet:
I2C-SDA
I2C-SCK
3.3V
SD-CS
SD-DI
SD-DO
SD-CLK
基準温度センサ
リレー駆動回路(FET?)

Board: 2 copper layers, 80.0 x 67.0 mm, 39 parts (1 on the bottom side), 40 nets.

## Commit log

2018-06-01 InitialCommit
